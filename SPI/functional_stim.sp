* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/tuan/Desktop/OpenRAM/technology/sky130A/models/tt.sp"
.include "sram_8_256_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_8_256_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 vdd gnd sram_8_256_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f

* Important signals for debug
* bl:	xsram_8_256_sky130a.xbank0.bl_0_0
* br:	xsram_8_256_sky130a.xbank0.br_0_0
* s_en:	xsram_8_256_sky130a.s_en
* q:	xsram_8_256_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xsram_8_256_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 00101111  to  address 00000000 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 01000101  to  address 00000000 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 01000011  to  address 00000110 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 01000011 from address 00000110 (from port 0) during cycle 4 (80ns - 100ns)
*	Reading 01000101 from address 00000000 (from port 0) during cycle 6 (120ns - 140ns)
*	Writing 01010111  to  address 11111101 (from port 0) during cycle 8 (160ns - 180ns)
*	Reading 01010111 from address 11111101 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 01000101 from address 00000000 (from port 0) during cycle 11 (220ns - 240ns)
*	Reading 01010111 from address 11111101 (from port 0) during cycle 12 (240ns - 260ns)
*	Writing 10111101  to  address 00000101 (from port 0) during cycle 13 (260ns - 280ns)
*	Writing 11010001  to  address 00000101 (from port 0) during cycle 14 (280ns - 300ns)
*	Reading 01010111 from address 11111101 (from port 0) during cycle 15 (300ns - 320ns)
*	Reading 11010001 from address 00000101 (from port 0) during cycle 16 (320ns - 340ns)
*	Writing 01011001  to  address 00000110 (from port 0) during cycle 17 (340ns - 360ns)
*	Reading 01010111 from address 11111101 (from port 0) during cycle 18 (360ns - 380ns)
*	Reading 01000101 from address 00000000 (from port 0) during cycle 21 (420ns - 440ns)
*	Writing 01010001  to  address 11111001 (from port 0) during cycle 22 (440ns - 460ns)
*	Reading 11010001 from address 00000101 (from port 0) during cycle 23 (460ns - 480ns)
*	Reading 01011001 from address 00000110 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 01010001 from address 11111001 (from port 0) during cycle 26 (520ns - 540ns)
*	Writing 00000101  to  address 00000010 (from port 0) during cycle 27 (540ns - 560ns)
*	Writing 00100101  to  address 11110111 (from port 0) during cycle 28 (560ns - 580ns)
*	Reading 01010111 from address 11111101 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 01010001 from address 11111001 (from port 0) during cycle 30 (600ns - 620ns)
*	Writing 00101110  to  address 00000101 (from port 0) during cycle 31 (620ns - 640ns)
*	Writing 01000110  to  address 11110111 (from port 0) during cycle 33 (660ns - 680ns)
*	Reading 00000101 from address 00000010 (from port 0) during cycle 34 (680ns - 700ns)
*	Reading 01011001 from address 00000110 (from port 0) during cycle 36 (720ns - 740ns)
*	Reading 01010001 from address 11111001 (from port 0) during cycle 37 (740ns - 760ns)
*	Reading 00101110 from address 00000101 (from port 0) during cycle 38 (760ns - 780ns)
*	Reading 01011001 from address 00000110 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 01010111 from address 11111101 (from port 0) during cycle 42 (840ns - 860ns)
*	Writing 10100101  to  address 00000110 (from port 0) during cycle 43 (860ns - 880ns)
*	Reading 01000110 from address 11110111 (from port 0) during cycle 44 (880ns - 900ns)
*	Reading 00000101 from address 00000010 (from port 0) during cycle 45 (900ns - 920ns)
*	Writing 00000100  to  address 11111101 (from port 0) during cycle 46 (920ns - 940ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 00000101 from address 00000010 (from port 0) during cycle 49 (980ns - 1000ns)
*	Reading 00000100 from address 11111101 (from port 0) during cycle 50 (1000ns - 1020ns)
*	Reading 00000101 from address 00000010 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Writing 01011000  to  address 11111110 (from port 0) during cycle 53 (1060ns - 1080ns)
*	Writing 11101000  to  address 11111101 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Reading 01000110 from address 11110111 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Reading 01000101 from address 00000000 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Reading 00101110 from address 00000101 (from port 0) during cycle 59 (1180ns - 1200ns)
*	Reading 01000101 from address 00000000 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Writing 00010001  to  address 11111000 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Reading 01011000 from address 11111110 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Reading 01011000 from address 11111110 (from port 0) during cycle 69 (1380ns - 1400ns)
*	Writing 00110110  to  address 00000101 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Writing 11101001  to  address 11111011 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Reading 01000101 from address 00000000 (from port 0) during cycle 73 (1460ns - 1480ns)
*	Reading 00000101 from address 00000010 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 76 (1520ns - 1540ns)
*	Reading 00110110 from address 00000101 (from port 0) during cycle 77 (1540ns - 1560ns)
*	Writing 11001101  to  address 00000010 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Reading 01000101 from address 00000000 (from port 0) during cycle 80 (1600ns - 1620ns)
*	Writing 01010010  to  address 11111100 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Reading 11101001 from address 11111011 (from port 0) during cycle 83 (1660ns - 1680ns)
*	Writing 11011010  to  address 11111110 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Writing 11101010  to  address 11111101 (from port 0) during cycle 85 (1700ns - 1720ns)
*	Writing 11100111  to  address 00000100 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Writing 11110001  to  address 00000000 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Reading 01010010 from address 11111100 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Reading 00110110 from address 00000101 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Reading 01010001 from address 11111001 (from port 0) during cycle 94 (1880ns - 1900ns)
*	Writing 10111100  to  address 00000111 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Writing 01111111  to  address 11111000 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 11011010 from address 11111110 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Reading 01010001 from address 11111001 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Reading 01010001 from address 11111001 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Writing 01000000  to  address 11111001 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Reading 11001101 from address 00000010 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Reading 11011010 from address 11111110 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Reading 11100111 from address 00000100 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Reading 01111111 from address 11111000 (from port 0) during cycle 107 (2140ns - 2160ns)
*	Reading 11101001 from address 11111011 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Writing 10010111  to  address 00000101 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Writing 00110000  to  address 00000000 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Writing 01100110  to  address 11110111 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Reading 11101001 from address 11111011 (from port 0) during cycle 113 (2260ns - 2280ns)
*	Reading 10010111 from address 00000101 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Reading 01100110 from address 11110111 (from port 0) during cycle 115 (2300ns - 2320ns)
*	Reading 11100111 from address 00000100 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Reading 11101010 from address 11111101 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Reading 01111111 from address 11111000 (from port 0) during cycle 118 (2360ns - 2380ns)
*	Reading 01000000 from address 11111001 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Reading 01100110 from address 11110111 (from port 0) during cycle 121 (2420ns - 2440ns)
*	Reading 10010111 from address 00000101 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Reading 00110000 from address 00000000 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Reading 11001101 from address 00000010 (from port 0) during cycle 125 (2500ns - 2520ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 127 (2540ns - 2560ns)
*	Reading 11100111 from address 00000100 (from port 0) during cycle 128 (2560ns - 2580ns)
*	Writing 01000111  to  address 00000101 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Reading 11011010 from address 11111110 (from port 0) during cycle 131 (2620ns - 2640ns)
*	Reading 00110000 from address 00000000 (from port 0) during cycle 132 (2640ns - 2660ns)
*	Reading 01000000 from address 11111001 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Writing 00010010  to  address 11111001 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Reading 01010010 from address 11111100 (from port 0) during cycle 137 (2740ns - 2760ns)
*	Reading 11011010 from address 11111110 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Reading 11001101 from address 00000010 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Reading 00010010 from address 11111001 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Reading 01010010 from address 11111100 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Writing 11011011  to  address 11111100 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Reading 11101001 from address 11111011 (from port 0) during cycle 145 (2900ns - 2920ns)
*	Reading 11101001 from address 11111011 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 11101010 from address 11111101 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Reading 00010010 from address 11111001 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Reading 11011010 from address 11111110 (from port 0) during cycle 150 (3000ns - 3020ns)
*	Reading 11100111 from address 00000100 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Reading 11001101 from address 00000010 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Reading 11011011 from address 11111100 (from port 0) during cycle 155 (3100ns - 3120ns)
*	Writing 11001100  to  address 11111010 (from port 0) during cycle 156 (3120ns - 3140ns)
*	Writing 10110000  to  address 00000010 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 11011010 from address 11111110 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Writing 11000001  to  address 00000100 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Reading 11101010 from address 11111101 (from port 0) during cycle 162 (3240ns - 3260ns)
*	Reading 11101010 from address 11111101 (from port 0) during cycle 163 (3260ns - 3280ns)
*	Reading 11001100 from address 11111010 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Reading 10111100 from address 00000111 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Reading 01111111 from address 11111000 (from port 0) during cycle 169 (3380ns - 3400ns)
*	Reading 10110000 from address 00000010 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Writing 00111100  to  address 00000010 (from port 0) during cycle 173 (3460ns - 3480ns)
*	Reading 00111100 from address 00000010 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Reading 11001100 from address 11111010 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 01100110 from address 11110111 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Reading 01111111 from address 11111000 (from port 0) during cycle 180 (3600ns - 3620ns)
*	Writing 10010111  to  address 11111101 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Reading 00110000 from address 00000000 (from port 0) during cycle 182 (3640ns - 3660ns)
*	Reading 10100101 from address 00000110 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 10111100 from address 00000111 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Reading 11000001 from address 00000100 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Reading 11000001 from address 00000100 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Reading 00110000 from address 00000000 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Reading 01111111 from address 11111000 (from port 0) during cycle 193 (3860ns - 3880ns)
*	Reading 00010010 from address 11111001 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Reading 00010010 from address 11111001 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Writing 10100001  to  address 11111100 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Reading 11101001 from address 11111011 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 00110000 from address 00000000 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Reading 00010010 from address 11111001 (from port 0) during cycle 201 (4020ns - 4040ns)
*	Writing 11001001  to  address 11111100 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Reading 10111100 from address 00000111 (from port 0) during cycle 203 (4060ns - 4080ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 0), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 1), (640, 1), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 0), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 0), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 1), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 0), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 0), (1560, 1), (1580, 1), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 1), (580, 1), (600, 0), (620, 1), (640, 1), (660, 1), (680, 0), (700, 0), (720, 1), (740, 0), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 1), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 0), (580, 1), (600, 1), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 1), (2120, 0), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 1), (2120, 0), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 1), (2120, 0), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 1), (2120, 0), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 0), (2100, 1), (2120, 0), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 0), (140, 1), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 1), (660, 0), (680, 0), (700, 1), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 0), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 1), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 0), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 0), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 0), (3580, 1), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 1), (480, 1), (500, 1), (520, 1), (540, 0), (560, 0), (580, 1), (600, 1), (620, 0), (640, 1), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 0), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_0 Vdout0_0ck6 = 1.8 time = 140
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=140.1n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 140
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=140.1n

* CHECK dout0_2 Vdout0_2ck6 = 1.8 time = 140
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=140.1n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 140
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=140.1n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 140
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=140.1n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 140
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=140.1n

* CHECK dout0_6 Vdout0_6ck6 = 1.8 time = 140
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=140.1n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 140
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=140.1n

* CHECK dout0_0 Vdout0_0ck10 = 1.8 time = 220
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=220.1n

* CHECK dout0_1 Vdout0_1ck10 = 1.8 time = 220
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=220.1n

* CHECK dout0_2 Vdout0_2ck10 = 1.8 time = 220
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=220.1n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 220
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=220.1n

* CHECK dout0_4 Vdout0_4ck10 = 1.8 time = 220
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=220.1n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 220
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=220.1n

* CHECK dout0_6 Vdout0_6ck10 = 1.8 time = 220
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=220.1n

* CHECK dout0_7 Vdout0_7ck10 = 0 time = 220
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=220.1n

* CHECK dout0_0 Vdout0_0ck11 = 1.8 time = 240
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=240.1n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 240
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=240.1n

* CHECK dout0_2 Vdout0_2ck11 = 1.8 time = 240
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=240.1n

* CHECK dout0_3 Vdout0_3ck11 = 0 time = 240
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=240.1n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 240
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=240.1n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 240
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=240.1n

* CHECK dout0_6 Vdout0_6ck11 = 1.8 time = 240
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=240.1n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 240
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=240.1n

* CHECK dout0_0 Vdout0_0ck12 = 1.8 time = 260
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=260.1n

* CHECK dout0_1 Vdout0_1ck12 = 1.8 time = 260
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=260.1n

* CHECK dout0_2 Vdout0_2ck12 = 1.8 time = 260
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=260.1n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 260
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=260.1n

* CHECK dout0_4 Vdout0_4ck12 = 1.8 time = 260
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=260.1n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 260
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=260.1n

* CHECK dout0_6 Vdout0_6ck12 = 1.8 time = 260
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=260.1n

* CHECK dout0_7 Vdout0_7ck12 = 0 time = 260
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=260.1n

* CHECK dout0_0 Vdout0_0ck15 = 1.8 time = 320
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=320.1n

* CHECK dout0_1 Vdout0_1ck15 = 1.8 time = 320
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=320.1n

* CHECK dout0_2 Vdout0_2ck15 = 1.8 time = 320
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=320.1n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 320
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=320.1n

* CHECK dout0_4 Vdout0_4ck15 = 1.8 time = 320
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=320.1n

* CHECK dout0_5 Vdout0_5ck15 = 0 time = 320
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=320.1n

* CHECK dout0_6 Vdout0_6ck15 = 1.8 time = 320
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=320.1n

* CHECK dout0_7 Vdout0_7ck15 = 0 time = 320
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=320.1n

* CHECK dout0_0 Vdout0_0ck16 = 1.8 time = 340
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=340.1n

* CHECK dout0_1 Vdout0_1ck16 = 0 time = 340
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=340.1n

* CHECK dout0_2 Vdout0_2ck16 = 0 time = 340
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=340.1n

* CHECK dout0_3 Vdout0_3ck16 = 0 time = 340
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=340.1n

* CHECK dout0_4 Vdout0_4ck16 = 1.8 time = 340
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=340.1n

* CHECK dout0_5 Vdout0_5ck16 = 0 time = 340
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=340.1n

* CHECK dout0_6 Vdout0_6ck16 = 1.8 time = 340
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=340.1n

* CHECK dout0_7 Vdout0_7ck16 = 1.8 time = 340
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=340.1n

* CHECK dout0_0 Vdout0_0ck18 = 1.8 time = 380
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=380.1n

* CHECK dout0_1 Vdout0_1ck18 = 1.8 time = 380
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=380.1n

* CHECK dout0_2 Vdout0_2ck18 = 1.8 time = 380
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=380.1n

* CHECK dout0_3 Vdout0_3ck18 = 0 time = 380
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=380.1n

* CHECK dout0_4 Vdout0_4ck18 = 1.8 time = 380
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=380.1n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 380
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=380.1n

* CHECK dout0_6 Vdout0_6ck18 = 1.8 time = 380
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=380.1n

* CHECK dout0_7 Vdout0_7ck18 = 0 time = 380
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=380.1n

* CHECK dout0_0 Vdout0_0ck21 = 1.8 time = 440
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=440.1n

* CHECK dout0_1 Vdout0_1ck21 = 0 time = 440
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=440.1n

* CHECK dout0_2 Vdout0_2ck21 = 1.8 time = 440
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=440.1n

* CHECK dout0_3 Vdout0_3ck21 = 0 time = 440
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=440.1n

* CHECK dout0_4 Vdout0_4ck21 = 0 time = 440
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=440.1n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 440
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=440.1n

* CHECK dout0_6 Vdout0_6ck21 = 1.8 time = 440
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=440.1n

* CHECK dout0_7 Vdout0_7ck21 = 0 time = 440
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=440.1n

* CHECK dout0_0 Vdout0_0ck23 = 1.8 time = 480
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=480.1n

* CHECK dout0_1 Vdout0_1ck23 = 0 time = 480
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=480.1n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 480
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=480.1n

* CHECK dout0_3 Vdout0_3ck23 = 0 time = 480
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=480.1n

* CHECK dout0_4 Vdout0_4ck23 = 1.8 time = 480
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=480.1n

* CHECK dout0_5 Vdout0_5ck23 = 0 time = 480
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=480.1n

* CHECK dout0_6 Vdout0_6ck23 = 1.8 time = 480
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=480.1n

* CHECK dout0_7 Vdout0_7ck23 = 1.8 time = 480
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=480.1n

* CHECK dout0_0 Vdout0_0ck25 = 1.8 time = 520
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=520.1n

* CHECK dout0_1 Vdout0_1ck25 = 0 time = 520
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=520.1n

* CHECK dout0_2 Vdout0_2ck25 = 0 time = 520
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=520.1n

* CHECK dout0_3 Vdout0_3ck25 = 1.8 time = 520
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=520.1n

* CHECK dout0_4 Vdout0_4ck25 = 1.8 time = 520
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=520.1n

* CHECK dout0_5 Vdout0_5ck25 = 0 time = 520
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=520.1n

* CHECK dout0_6 Vdout0_6ck25 = 1.8 time = 520
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=520.1n

* CHECK dout0_7 Vdout0_7ck25 = 0 time = 520
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=520.1n

* CHECK dout0_0 Vdout0_0ck26 = 1.8 time = 540
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=540.1n

* CHECK dout0_1 Vdout0_1ck26 = 0 time = 540
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=540.1n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 540
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=540.1n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 540
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=540.1n

* CHECK dout0_4 Vdout0_4ck26 = 1.8 time = 540
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=540.1n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 540
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=540.1n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 540
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=540.1n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 540
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=540.1n

* CHECK dout0_0 Vdout0_0ck29 = 1.8 time = 600
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=600.1n

* CHECK dout0_1 Vdout0_1ck29 = 1.8 time = 600
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=600.1n

* CHECK dout0_2 Vdout0_2ck29 = 1.8 time = 600
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=600.1n

* CHECK dout0_3 Vdout0_3ck29 = 0 time = 600
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=600.1n

* CHECK dout0_4 Vdout0_4ck29 = 1.8 time = 600
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=600.1n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 600
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=600.1n

* CHECK dout0_6 Vdout0_6ck29 = 1.8 time = 600
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=600.1n

* CHECK dout0_7 Vdout0_7ck29 = 0 time = 600
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=600.1n

* CHECK dout0_0 Vdout0_0ck30 = 1.8 time = 620
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=620.1n

* CHECK dout0_1 Vdout0_1ck30 = 0 time = 620
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=620.1n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 620
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=620.1n

* CHECK dout0_3 Vdout0_3ck30 = 0 time = 620
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=620.1n

* CHECK dout0_4 Vdout0_4ck30 = 1.8 time = 620
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=620.1n

* CHECK dout0_5 Vdout0_5ck30 = 0 time = 620
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=620.1n

* CHECK dout0_6 Vdout0_6ck30 = 1.8 time = 620
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=620.1n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 620
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=620.1n

* CHECK dout0_0 Vdout0_0ck34 = 1.8 time = 700
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=700.1n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 700
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=700.1n

* CHECK dout0_2 Vdout0_2ck34 = 1.8 time = 700
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=700.1n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 700
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=700.1n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 700
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=700.1n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 700
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=700.1n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 700
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=700.1n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 700
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=700.1n

* CHECK dout0_0 Vdout0_0ck36 = 1.8 time = 740
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=740.1n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 740
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=740.1n

* CHECK dout0_2 Vdout0_2ck36 = 0 time = 740
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=740.1n

* CHECK dout0_3 Vdout0_3ck36 = 1.8 time = 740
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=740.1n

* CHECK dout0_4 Vdout0_4ck36 = 1.8 time = 740
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=740.1n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 740
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=740.1n

* CHECK dout0_6 Vdout0_6ck36 = 1.8 time = 740
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=740.1n

* CHECK dout0_7 Vdout0_7ck36 = 0 time = 740
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=740.1n

* CHECK dout0_0 Vdout0_0ck37 = 1.8 time = 760
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=760.1n

* CHECK dout0_1 Vdout0_1ck37 = 0 time = 760
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=760.1n

* CHECK dout0_2 Vdout0_2ck37 = 0 time = 760
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=760.1n

* CHECK dout0_3 Vdout0_3ck37 = 0 time = 760
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=760.1n

* CHECK dout0_4 Vdout0_4ck37 = 1.8 time = 760
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=760.1n

* CHECK dout0_5 Vdout0_5ck37 = 0 time = 760
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=760.1n

* CHECK dout0_6 Vdout0_6ck37 = 1.8 time = 760
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=760.1n

* CHECK dout0_7 Vdout0_7ck37 = 0 time = 760
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=760.1n

* CHECK dout0_0 Vdout0_0ck38 = 0 time = 780
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=780.1n

* CHECK dout0_1 Vdout0_1ck38 = 1.8 time = 780
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=780.1n

* CHECK dout0_2 Vdout0_2ck38 = 1.8 time = 780
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=780.1n

* CHECK dout0_3 Vdout0_3ck38 = 1.8 time = 780
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=780.1n

* CHECK dout0_4 Vdout0_4ck38 = 0 time = 780
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=780.1n

* CHECK dout0_5 Vdout0_5ck38 = 1.8 time = 780
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=780.1n

* CHECK dout0_6 Vdout0_6ck38 = 0 time = 780
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=780.1n

* CHECK dout0_7 Vdout0_7ck38 = 0 time = 780
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=780.1n

* CHECK dout0_0 Vdout0_0ck41 = 1.8 time = 840
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=840.1n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 840
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=840.1n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 840
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=840.1n

* CHECK dout0_3 Vdout0_3ck41 = 1.8 time = 840
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=840.1n

* CHECK dout0_4 Vdout0_4ck41 = 1.8 time = 840
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=840.1n

* CHECK dout0_5 Vdout0_5ck41 = 0 time = 840
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=840.1n

* CHECK dout0_6 Vdout0_6ck41 = 1.8 time = 840
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=840.1n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 840
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=840.1n

* CHECK dout0_0 Vdout0_0ck42 = 1.8 time = 860
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=860.1n

* CHECK dout0_1 Vdout0_1ck42 = 1.8 time = 860
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=860.1n

* CHECK dout0_2 Vdout0_2ck42 = 1.8 time = 860
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=860.1n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 860
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=860.1n

* CHECK dout0_4 Vdout0_4ck42 = 1.8 time = 860
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=860.1n

* CHECK dout0_5 Vdout0_5ck42 = 0 time = 860
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=860.1n

* CHECK dout0_6 Vdout0_6ck42 = 1.8 time = 860
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=860.1n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 860
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=860.1n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 900
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=900.1n

* CHECK dout0_1 Vdout0_1ck44 = 1.8 time = 900
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=900.1n

* CHECK dout0_2 Vdout0_2ck44 = 1.8 time = 900
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=900.1n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 900
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=900.1n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 900
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=900.1n

* CHECK dout0_5 Vdout0_5ck44 = 0 time = 900
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=900.1n

* CHECK dout0_6 Vdout0_6ck44 = 1.8 time = 900
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=900.1n

* CHECK dout0_7 Vdout0_7ck44 = 0 time = 900
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=900.1n

* CHECK dout0_0 Vdout0_0ck45 = 1.8 time = 920
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=920.1n

* CHECK dout0_1 Vdout0_1ck45 = 0 time = 920
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=920.1n

* CHECK dout0_2 Vdout0_2ck45 = 1.8 time = 920
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=920.1n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 920
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=920.1n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 920
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=920.1n

* CHECK dout0_5 Vdout0_5ck45 = 0 time = 920
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=920.1n

* CHECK dout0_6 Vdout0_6ck45 = 0 time = 920
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=920.1n

* CHECK dout0_7 Vdout0_7ck45 = 0 time = 920
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=920.1n

* CHECK dout0_0 Vdout0_0ck47 = 1.8 time = 960
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=960.1n

* CHECK dout0_1 Vdout0_1ck47 = 0 time = 960
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=960.1n

* CHECK dout0_2 Vdout0_2ck47 = 1.8 time = 960
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=960.1n

* CHECK dout0_3 Vdout0_3ck47 = 0 time = 960
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=960.1n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 960
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=960.1n

* CHECK dout0_5 Vdout0_5ck47 = 1.8 time = 960
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=960.1n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 960
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=960.1n

* CHECK dout0_7 Vdout0_7ck47 = 1.8 time = 960
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=960.1n

* CHECK dout0_0 Vdout0_0ck49 = 1.8 time = 1000
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=1000.1n

* CHECK dout0_1 Vdout0_1ck49 = 0 time = 1000
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=1000.1n

* CHECK dout0_2 Vdout0_2ck49 = 1.8 time = 1000
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=1000.1n

* CHECK dout0_3 Vdout0_3ck49 = 0 time = 1000
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=1000.1n

* CHECK dout0_4 Vdout0_4ck49 = 0 time = 1000
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=1000.1n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 1000
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=1000.1n

* CHECK dout0_6 Vdout0_6ck49 = 0 time = 1000
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=1000.1n

* CHECK dout0_7 Vdout0_7ck49 = 0 time = 1000
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=1000.1n

* CHECK dout0_0 Vdout0_0ck50 = 0 time = 1020
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=1020.1n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 1020
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=1020.1n

* CHECK dout0_2 Vdout0_2ck50 = 1.8 time = 1020
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=1020.1n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 1020
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=1020.1n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 1020
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=1020.1n

* CHECK dout0_5 Vdout0_5ck50 = 0 time = 1020
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=1020.1n

* CHECK dout0_6 Vdout0_6ck50 = 0 time = 1020
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=1020.1n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 1020
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=1020.1n

* CHECK dout0_0 Vdout0_0ck51 = 1.8 time = 1040
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=1040.1n

* CHECK dout0_1 Vdout0_1ck51 = 0 time = 1040
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=1040.1n

* CHECK dout0_2 Vdout0_2ck51 = 1.8 time = 1040
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=1040.1n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 1040
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=1040.1n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 1040
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=1040.1n

* CHECK dout0_5 Vdout0_5ck51 = 0 time = 1040
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=1040.1n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 1040
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=1040.1n

* CHECK dout0_7 Vdout0_7ck51 = 0 time = 1040
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=1040.1n

* CHECK dout0_0 Vdout0_0ck56 = 0 time = 1140
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=1140.1n

* CHECK dout0_1 Vdout0_1ck56 = 1.8 time = 1140
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=1140.1n

* CHECK dout0_2 Vdout0_2ck56 = 1.8 time = 1140
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=1140.1n

* CHECK dout0_3 Vdout0_3ck56 = 0 time = 1140
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=1140.1n

* CHECK dout0_4 Vdout0_4ck56 = 0 time = 1140
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=1140.1n

* CHECK dout0_5 Vdout0_5ck56 = 0 time = 1140
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=1140.1n

* CHECK dout0_6 Vdout0_6ck56 = 1.8 time = 1140
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=1140.1n

* CHECK dout0_7 Vdout0_7ck56 = 0 time = 1140
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=1140.1n

* CHECK dout0_0 Vdout0_0ck57 = 1.8 time = 1160
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=1160.1n

* CHECK dout0_1 Vdout0_1ck57 = 0 time = 1160
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=1160.1n

* CHECK dout0_2 Vdout0_2ck57 = 1.8 time = 1160
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=1160.1n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 1160
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=1160.1n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 1160
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=1160.1n

* CHECK dout0_5 Vdout0_5ck57 = 0 time = 1160
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=1160.1n

* CHECK dout0_6 Vdout0_6ck57 = 1.8 time = 1160
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=1160.1n

* CHECK dout0_7 Vdout0_7ck57 = 0 time = 1160
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=1160.1n

* CHECK dout0_0 Vdout0_0ck59 = 0 time = 1200
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=1200.1n

* CHECK dout0_1 Vdout0_1ck59 = 1.8 time = 1200
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=1200.1n

* CHECK dout0_2 Vdout0_2ck59 = 1.8 time = 1200
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=1200.1n

* CHECK dout0_3 Vdout0_3ck59 = 1.8 time = 1200
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=1200.1n

* CHECK dout0_4 Vdout0_4ck59 = 0 time = 1200
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=1200.1n

* CHECK dout0_5 Vdout0_5ck59 = 1.8 time = 1200
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=1200.1n

* CHECK dout0_6 Vdout0_6ck59 = 0 time = 1200
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=1200.1n

* CHECK dout0_7 Vdout0_7ck59 = 0 time = 1200
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=1200.1n

* CHECK dout0_0 Vdout0_0ck64 = 1.8 time = 1300
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=1300.1n

* CHECK dout0_1 Vdout0_1ck64 = 0 time = 1300
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=1300.1n

* CHECK dout0_2 Vdout0_2ck64 = 1.8 time = 1300
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=1300.1n

* CHECK dout0_3 Vdout0_3ck64 = 0 time = 1300
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=1300.1n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 1300
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=1300.1n

* CHECK dout0_5 Vdout0_5ck64 = 0 time = 1300
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=1300.1n

* CHECK dout0_6 Vdout0_6ck64 = 1.8 time = 1300
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=1300.1n

* CHECK dout0_7 Vdout0_7ck64 = 0 time = 1300
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=1300.1n

* CHECK dout0_0 Vdout0_0ck65 = 1.8 time = 1320
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=1320.1n

* CHECK dout0_1 Vdout0_1ck65 = 0 time = 1320
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=1320.1n

* CHECK dout0_2 Vdout0_2ck65 = 1.8 time = 1320
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=1320.1n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 1320
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=1320.1n

* CHECK dout0_4 Vdout0_4ck65 = 0 time = 1320
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=1320.1n

* CHECK dout0_5 Vdout0_5ck65 = 1.8 time = 1320
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=1320.1n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 1320
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=1320.1n

* CHECK dout0_7 Vdout0_7ck65 = 1.8 time = 1320
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=1320.1n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 1360
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=1360.1n

* CHECK dout0_1 Vdout0_1ck67 = 0 time = 1360
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=1360.1n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 1360
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=1360.1n

* CHECK dout0_3 Vdout0_3ck67 = 1.8 time = 1360
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=1360.1n

* CHECK dout0_4 Vdout0_4ck67 = 1.8 time = 1360
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=1360.1n

* CHECK dout0_5 Vdout0_5ck67 = 0 time = 1360
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=1360.1n

* CHECK dout0_6 Vdout0_6ck67 = 1.8 time = 1360
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=1360.1n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 1360
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=1360.1n

* CHECK dout0_0 Vdout0_0ck68 = 1.8 time = 1380
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=1380.1n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 1380
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=1380.1n

* CHECK dout0_2 Vdout0_2ck68 = 1.8 time = 1380
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=1380.1n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 1380
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=1380.1n

* CHECK dout0_4 Vdout0_4ck68 = 0 time = 1380
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=1380.1n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 1380
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=1380.1n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 1380
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=1380.1n

* CHECK dout0_7 Vdout0_7ck68 = 1.8 time = 1380
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=1380.1n

* CHECK dout0_0 Vdout0_0ck69 = 0 time = 1400
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=1400.1n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 1400
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=1400.1n

* CHECK dout0_2 Vdout0_2ck69 = 0 time = 1400
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=1400.1n

* CHECK dout0_3 Vdout0_3ck69 = 1.8 time = 1400
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=1400.1n

* CHECK dout0_4 Vdout0_4ck69 = 1.8 time = 1400
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=1400.1n

* CHECK dout0_5 Vdout0_5ck69 = 0 time = 1400
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=1400.1n

* CHECK dout0_6 Vdout0_6ck69 = 1.8 time = 1400
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=1400.1n

* CHECK dout0_7 Vdout0_7ck69 = 0 time = 1400
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=1400.1n

* CHECK dout0_0 Vdout0_0ck73 = 1.8 time = 1480
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=1480.1n

* CHECK dout0_1 Vdout0_1ck73 = 0 time = 1480
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=1480.1n

* CHECK dout0_2 Vdout0_2ck73 = 1.8 time = 1480
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=1480.1n

* CHECK dout0_3 Vdout0_3ck73 = 0 time = 1480
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=1480.1n

* CHECK dout0_4 Vdout0_4ck73 = 0 time = 1480
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=1480.1n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 1480
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=1480.1n

* CHECK dout0_6 Vdout0_6ck73 = 1.8 time = 1480
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=1480.1n

* CHECK dout0_7 Vdout0_7ck73 = 0 time = 1480
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=1480.1n

* CHECK dout0_0 Vdout0_0ck75 = 1.8 time = 1520
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=1520.1n

* CHECK dout0_1 Vdout0_1ck75 = 0 time = 1520
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=1520.1n

* CHECK dout0_2 Vdout0_2ck75 = 1.8 time = 1520
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=1520.1n

* CHECK dout0_3 Vdout0_3ck75 = 0 time = 1520
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=1520.1n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 1520
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=1520.1n

* CHECK dout0_5 Vdout0_5ck75 = 0 time = 1520
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=1520.1n

* CHECK dout0_6 Vdout0_6ck75 = 0 time = 1520
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=1520.1n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 1520
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=1520.1n

* CHECK dout0_0 Vdout0_0ck76 = 1.8 time = 1540
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=1540.1n

* CHECK dout0_1 Vdout0_1ck76 = 0 time = 1540
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=1540.1n

* CHECK dout0_2 Vdout0_2ck76 = 1.8 time = 1540
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=1540.1n

* CHECK dout0_3 Vdout0_3ck76 = 0 time = 1540
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=1540.1n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 1540
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=1540.1n

* CHECK dout0_5 Vdout0_5ck76 = 1.8 time = 1540
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=1540.1n

* CHECK dout0_6 Vdout0_6ck76 = 0 time = 1540
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=1540.1n

* CHECK dout0_7 Vdout0_7ck76 = 1.8 time = 1540
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=1540.1n

* CHECK dout0_0 Vdout0_0ck77 = 0 time = 1560
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=1560.1n

* CHECK dout0_1 Vdout0_1ck77 = 1.8 time = 1560
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=1560.1n

* CHECK dout0_2 Vdout0_2ck77 = 1.8 time = 1560
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=1560.1n

* CHECK dout0_3 Vdout0_3ck77 = 0 time = 1560
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=1560.1n

* CHECK dout0_4 Vdout0_4ck77 = 1.8 time = 1560
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=1560.1n

* CHECK dout0_5 Vdout0_5ck77 = 1.8 time = 1560
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=1560.1n

* CHECK dout0_6 Vdout0_6ck77 = 0 time = 1560
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=1560.1n

* CHECK dout0_7 Vdout0_7ck77 = 0 time = 1560
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=1560.1n

* CHECK dout0_0 Vdout0_0ck80 = 1.8 time = 1620
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=1620.1n

* CHECK dout0_1 Vdout0_1ck80 = 0 time = 1620
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=1620.1n

* CHECK dout0_2 Vdout0_2ck80 = 1.8 time = 1620
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=1620.1n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 1620
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=1620.1n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 1620
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=1620.1n

* CHECK dout0_5 Vdout0_5ck80 = 0 time = 1620
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=1620.1n

* CHECK dout0_6 Vdout0_6ck80 = 1.8 time = 1620
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=1620.1n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 1620
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=1620.1n

* CHECK dout0_0 Vdout0_0ck83 = 1.8 time = 1680
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=1680.1n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 1680
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=1680.1n

* CHECK dout0_2 Vdout0_2ck83 = 0 time = 1680
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=1680.1n

* CHECK dout0_3 Vdout0_3ck83 = 1.8 time = 1680
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=1680.1n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 1680
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=1680.1n

* CHECK dout0_5 Vdout0_5ck83 = 1.8 time = 1680
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=1680.1n

* CHECK dout0_6 Vdout0_6ck83 = 1.8 time = 1680
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=1680.1n

* CHECK dout0_7 Vdout0_7ck83 = 1.8 time = 1680
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=1680.1n

* CHECK dout0_0 Vdout0_0ck90 = 0 time = 1820
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=1820.1n

* CHECK dout0_1 Vdout0_1ck90 = 1.8 time = 1820
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=1820.1n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 1820
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=1820.1n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 1820
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=1820.1n

* CHECK dout0_4 Vdout0_4ck90 = 1.8 time = 1820
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=1820.1n

* CHECK dout0_5 Vdout0_5ck90 = 0 time = 1820
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=1820.1n

* CHECK dout0_6 Vdout0_6ck90 = 1.8 time = 1820
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=1820.1n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 1820
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=1820.1n

* CHECK dout0_0 Vdout0_0ck92 = 0 time = 1860
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=1860.1n

* CHECK dout0_1 Vdout0_1ck92 = 1.8 time = 1860
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=1860.1n

* CHECK dout0_2 Vdout0_2ck92 = 1.8 time = 1860
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=1860.1n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 1860
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=1860.1n

* CHECK dout0_4 Vdout0_4ck92 = 1.8 time = 1860
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=1860.1n

* CHECK dout0_5 Vdout0_5ck92 = 1.8 time = 1860
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=1860.1n

* CHECK dout0_6 Vdout0_6ck92 = 0 time = 1860
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=1860.1n

* CHECK dout0_7 Vdout0_7ck92 = 0 time = 1860
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=1860.1n

* CHECK dout0_0 Vdout0_0ck93 = 1.8 time = 1880
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=1880.1n

* CHECK dout0_1 Vdout0_1ck93 = 0 time = 1880
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=1880.1n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 1880
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=1880.1n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 1880
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=1880.1n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 1880
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=1880.1n

* CHECK dout0_5 Vdout0_5ck93 = 1.8 time = 1880
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=1880.1n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 1880
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=1880.1n

* CHECK dout0_7 Vdout0_7ck93 = 1.8 time = 1880
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=1880.1n

* CHECK dout0_0 Vdout0_0ck94 = 1.8 time = 1900
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=1900.1n

* CHECK dout0_1 Vdout0_1ck94 = 0 time = 1900
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=1900.1n

* CHECK dout0_2 Vdout0_2ck94 = 0 time = 1900
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=1900.1n

* CHECK dout0_3 Vdout0_3ck94 = 0 time = 1900
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=1900.1n

* CHECK dout0_4 Vdout0_4ck94 = 1.8 time = 1900
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=1900.1n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 1900
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=1900.1n

* CHECK dout0_6 Vdout0_6ck94 = 1.8 time = 1900
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=1900.1n

* CHECK dout0_7 Vdout0_7ck94 = 0 time = 1900
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=1900.1n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 1960
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=1960.1n

* CHECK dout0_1 Vdout0_1ck97 = 1.8 time = 1960
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=1960.1n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 1960
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=1960.1n

* CHECK dout0_3 Vdout0_3ck97 = 1.8 time = 1960
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=1960.1n

* CHECK dout0_4 Vdout0_4ck97 = 1.8 time = 1960
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=1960.1n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 1960
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=1960.1n

* CHECK dout0_6 Vdout0_6ck97 = 1.8 time = 1960
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=1960.1n

* CHECK dout0_7 Vdout0_7ck97 = 1.8 time = 1960
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=1960.1n

* CHECK dout0_0 Vdout0_0ck98 = 1.8 time = 1980
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=1980.1n

* CHECK dout0_1 Vdout0_1ck98 = 0 time = 1980
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=1980.1n

* CHECK dout0_2 Vdout0_2ck98 = 0 time = 1980
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=1980.1n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 1980
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=1980.1n

* CHECK dout0_4 Vdout0_4ck98 = 1.8 time = 1980
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=1980.1n

* CHECK dout0_5 Vdout0_5ck98 = 0 time = 1980
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=1980.1n

* CHECK dout0_6 Vdout0_6ck98 = 1.8 time = 1980
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=1980.1n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 1980
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=1980.1n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 2000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=2000.1n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 2000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=2000.1n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 2000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=2000.1n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 2000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=2000.1n

* CHECK dout0_4 Vdout0_4ck99 = 1.8 time = 2000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=2000.1n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 2000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=2000.1n

* CHECK dout0_6 Vdout0_6ck99 = 1.8 time = 2000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=2000.1n

* CHECK dout0_7 Vdout0_7ck99 = 0 time = 2000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=2000.1n

* CHECK dout0_0 Vdout0_0ck101 = 1.8 time = 2040
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=2040.1n

* CHECK dout0_1 Vdout0_1ck101 = 0 time = 2040
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=2040.1n

* CHECK dout0_2 Vdout0_2ck101 = 1.8 time = 2040
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=2040.1n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 2040
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=2040.1n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 2040
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=2040.1n

* CHECK dout0_5 Vdout0_5ck101 = 1.8 time = 2040
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=2040.1n

* CHECK dout0_6 Vdout0_6ck101 = 0 time = 2040
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=2040.1n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 2040
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=2040.1n

* CHECK dout0_0 Vdout0_0ck104 = 1.8 time = 2100
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=2100.1n

* CHECK dout0_1 Vdout0_1ck104 = 0 time = 2100
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=2100.1n

* CHECK dout0_2 Vdout0_2ck104 = 1.8 time = 2100
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=2100.1n

* CHECK dout0_3 Vdout0_3ck104 = 1.8 time = 2100
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=2100.1n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 2100
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=2100.1n

* CHECK dout0_5 Vdout0_5ck104 = 0 time = 2100
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=2100.1n

* CHECK dout0_6 Vdout0_6ck104 = 1.8 time = 2100
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=2100.1n

* CHECK dout0_7 Vdout0_7ck104 = 1.8 time = 2100
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=2100.1n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 2120
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=2120.1n

* CHECK dout0_1 Vdout0_1ck105 = 1.8 time = 2120
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=2120.1n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 2120
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=2120.1n

* CHECK dout0_3 Vdout0_3ck105 = 1.8 time = 2120
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=2120.1n

* CHECK dout0_4 Vdout0_4ck105 = 1.8 time = 2120
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=2120.1n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 2120
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=2120.1n

* CHECK dout0_6 Vdout0_6ck105 = 1.8 time = 2120
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=2120.1n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 2120
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=2120.1n

* CHECK dout0_0 Vdout0_0ck106 = 1.8 time = 2140
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=2140.1n

* CHECK dout0_1 Vdout0_1ck106 = 1.8 time = 2140
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=2140.1n

* CHECK dout0_2 Vdout0_2ck106 = 1.8 time = 2140
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=2140.1n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 2140
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=2140.1n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 2140
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=2140.1n

* CHECK dout0_5 Vdout0_5ck106 = 1.8 time = 2140
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=2140.1n

* CHECK dout0_6 Vdout0_6ck106 = 1.8 time = 2140
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=2140.1n

* CHECK dout0_7 Vdout0_7ck106 = 1.8 time = 2140
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=2140.1n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 2160
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=2160.1n

* CHECK dout0_1 Vdout0_1ck107 = 1.8 time = 2160
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=2160.1n

* CHECK dout0_2 Vdout0_2ck107 = 1.8 time = 2160
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=2160.1n

* CHECK dout0_3 Vdout0_3ck107 = 1.8 time = 2160
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=2160.1n

* CHECK dout0_4 Vdout0_4ck107 = 1.8 time = 2160
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=2160.1n

* CHECK dout0_5 Vdout0_5ck107 = 1.8 time = 2160
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=2160.1n

* CHECK dout0_6 Vdout0_6ck107 = 1.8 time = 2160
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=2160.1n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 2160
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=2160.1n

* CHECK dout0_0 Vdout0_0ck108 = 1.8 time = 2180
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=2180.1n

* CHECK dout0_1 Vdout0_1ck108 = 0 time = 2180
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=2180.1n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 2180
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=2180.1n

* CHECK dout0_3 Vdout0_3ck108 = 1.8 time = 2180
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=2180.1n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 2180
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=2180.1n

* CHECK dout0_5 Vdout0_5ck108 = 1.8 time = 2180
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=2180.1n

* CHECK dout0_6 Vdout0_6ck108 = 1.8 time = 2180
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=2180.1n

* CHECK dout0_7 Vdout0_7ck108 = 1.8 time = 2180
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=2180.1n

* CHECK dout0_0 Vdout0_0ck111 = 1.8 time = 2240
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=2240.1n

* CHECK dout0_1 Vdout0_1ck111 = 0 time = 2240
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=2240.1n

* CHECK dout0_2 Vdout0_2ck111 = 1.8 time = 2240
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=2240.1n

* CHECK dout0_3 Vdout0_3ck111 = 0 time = 2240
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=2240.1n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 2240
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=2240.1n

* CHECK dout0_5 Vdout0_5ck111 = 1.8 time = 2240
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=2240.1n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 2240
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=2240.1n

* CHECK dout0_7 Vdout0_7ck111 = 1.8 time = 2240
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=2240.1n

* CHECK dout0_0 Vdout0_0ck113 = 1.8 time = 2280
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=2280.1n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 2280
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=2280.1n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 2280
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=2280.1n

* CHECK dout0_3 Vdout0_3ck113 = 1.8 time = 2280
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=2280.1n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 2280
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=2280.1n

* CHECK dout0_5 Vdout0_5ck113 = 1.8 time = 2280
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=2280.1n

* CHECK dout0_6 Vdout0_6ck113 = 1.8 time = 2280
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=2280.1n

* CHECK dout0_7 Vdout0_7ck113 = 1.8 time = 2280
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=2280.1n

* CHECK dout0_0 Vdout0_0ck114 = 1.8 time = 2300
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=2300.1n

* CHECK dout0_1 Vdout0_1ck114 = 1.8 time = 2300
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=2300.1n

* CHECK dout0_2 Vdout0_2ck114 = 1.8 time = 2300
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=2300.1n

* CHECK dout0_3 Vdout0_3ck114 = 0 time = 2300
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=2300.1n

* CHECK dout0_4 Vdout0_4ck114 = 1.8 time = 2300
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=2300.1n

* CHECK dout0_5 Vdout0_5ck114 = 0 time = 2300
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=2300.1n

* CHECK dout0_6 Vdout0_6ck114 = 0 time = 2300
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=2300.1n

* CHECK dout0_7 Vdout0_7ck114 = 1.8 time = 2300
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=2300.1n

* CHECK dout0_0 Vdout0_0ck115 = 0 time = 2320
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=2320.1n

* CHECK dout0_1 Vdout0_1ck115 = 1.8 time = 2320
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=2320.1n

* CHECK dout0_2 Vdout0_2ck115 = 1.8 time = 2320
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=2320.1n

* CHECK dout0_3 Vdout0_3ck115 = 0 time = 2320
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=2320.1n

* CHECK dout0_4 Vdout0_4ck115 = 0 time = 2320
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=2320.1n

* CHECK dout0_5 Vdout0_5ck115 = 1.8 time = 2320
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=2320.1n

* CHECK dout0_6 Vdout0_6ck115 = 1.8 time = 2320
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=2320.1n

* CHECK dout0_7 Vdout0_7ck115 = 0 time = 2320
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=2320.1n

* CHECK dout0_0 Vdout0_0ck116 = 1.8 time = 2340
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=2340.1n

* CHECK dout0_1 Vdout0_1ck116 = 1.8 time = 2340
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=2340.1n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 2340
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=2340.1n

* CHECK dout0_3 Vdout0_3ck116 = 0 time = 2340
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=2340.1n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 2340
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=2340.1n

* CHECK dout0_5 Vdout0_5ck116 = 1.8 time = 2340
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=2340.1n

* CHECK dout0_6 Vdout0_6ck116 = 1.8 time = 2340
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=2340.1n

* CHECK dout0_7 Vdout0_7ck116 = 1.8 time = 2340
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=2340.1n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 2360
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=2360.1n

* CHECK dout0_1 Vdout0_1ck117 = 1.8 time = 2360
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=2360.1n

* CHECK dout0_2 Vdout0_2ck117 = 0 time = 2360
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=2360.1n

* CHECK dout0_3 Vdout0_3ck117 = 1.8 time = 2360
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=2360.1n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 2360
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=2360.1n

* CHECK dout0_5 Vdout0_5ck117 = 1.8 time = 2360
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=2360.1n

* CHECK dout0_6 Vdout0_6ck117 = 1.8 time = 2360
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=2360.1n

* CHECK dout0_7 Vdout0_7ck117 = 1.8 time = 2360
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=2360.1n

* CHECK dout0_0 Vdout0_0ck118 = 1.8 time = 2380
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=2380.1n

* CHECK dout0_1 Vdout0_1ck118 = 1.8 time = 2380
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=2380.1n

* CHECK dout0_2 Vdout0_2ck118 = 1.8 time = 2380
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=2380.1n

* CHECK dout0_3 Vdout0_3ck118 = 1.8 time = 2380
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=2380.1n

* CHECK dout0_4 Vdout0_4ck118 = 1.8 time = 2380
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=2380.1n

* CHECK dout0_5 Vdout0_5ck118 = 1.8 time = 2380
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=2380.1n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 2380
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=2380.1n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 2380
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=2380.1n

* CHECK dout0_0 Vdout0_0ck119 = 0 time = 2400
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=2400.1n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 2400
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=2400.1n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 2400
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=2400.1n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 2400
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=2400.1n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 2400
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=2400.1n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 2400
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=2400.1n

* CHECK dout0_6 Vdout0_6ck119 = 1.8 time = 2400
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=2400.1n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 2400
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=2400.1n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 2440
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=2440.1n

* CHECK dout0_1 Vdout0_1ck121 = 1.8 time = 2440
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=2440.1n

* CHECK dout0_2 Vdout0_2ck121 = 1.8 time = 2440
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=2440.1n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 2440
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=2440.1n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 2440
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=2440.1n

* CHECK dout0_5 Vdout0_5ck121 = 1.8 time = 2440
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=2440.1n

* CHECK dout0_6 Vdout0_6ck121 = 1.8 time = 2440
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=2440.1n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 2440
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=2440.1n

* CHECK dout0_0 Vdout0_0ck122 = 1.8 time = 2460
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=2460.1n

* CHECK dout0_1 Vdout0_1ck122 = 1.8 time = 2460
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=2460.1n

* CHECK dout0_2 Vdout0_2ck122 = 1.8 time = 2460
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=2460.1n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 2460
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=2460.1n

* CHECK dout0_4 Vdout0_4ck122 = 1.8 time = 2460
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=2460.1n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 2460
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=2460.1n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 2460
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=2460.1n

* CHECK dout0_7 Vdout0_7ck122 = 1.8 time = 2460
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=2460.1n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 2480
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=2480.1n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 2480
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=2480.1n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 2480
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=2480.1n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 2480
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=2480.1n

* CHECK dout0_4 Vdout0_4ck123 = 1.8 time = 2480
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=2480.1n

* CHECK dout0_5 Vdout0_5ck123 = 1.8 time = 2480
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=2480.1n

* CHECK dout0_6 Vdout0_6ck123 = 0 time = 2480
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=2480.1n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 2480
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=2480.1n

* CHECK dout0_0 Vdout0_0ck125 = 1.8 time = 2520
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=2520.1n

* CHECK dout0_1 Vdout0_1ck125 = 0 time = 2520
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=2520.1n

* CHECK dout0_2 Vdout0_2ck125 = 1.8 time = 2520
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=2520.1n

* CHECK dout0_3 Vdout0_3ck125 = 1.8 time = 2520
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=2520.1n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 2520
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=2520.1n

* CHECK dout0_5 Vdout0_5ck125 = 0 time = 2520
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=2520.1n

* CHECK dout0_6 Vdout0_6ck125 = 1.8 time = 2520
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=2520.1n

* CHECK dout0_7 Vdout0_7ck125 = 1.8 time = 2520
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=2520.1n

* CHECK dout0_0 Vdout0_0ck127 = 1.8 time = 2560
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=2560.1n

* CHECK dout0_1 Vdout0_1ck127 = 0 time = 2560
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=2560.1n

* CHECK dout0_2 Vdout0_2ck127 = 1.8 time = 2560
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=2560.1n

* CHECK dout0_3 Vdout0_3ck127 = 0 time = 2560
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=2560.1n

* CHECK dout0_4 Vdout0_4ck127 = 0 time = 2560
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=2560.1n

* CHECK dout0_5 Vdout0_5ck127 = 1.8 time = 2560
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=2560.1n

* CHECK dout0_6 Vdout0_6ck127 = 0 time = 2560
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=2560.1n

* CHECK dout0_7 Vdout0_7ck127 = 1.8 time = 2560
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=2560.1n

* CHECK dout0_0 Vdout0_0ck128 = 1.8 time = 2580
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=2580.1n

* CHECK dout0_1 Vdout0_1ck128 = 1.8 time = 2580
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=2580.1n

* CHECK dout0_2 Vdout0_2ck128 = 1.8 time = 2580
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=2580.1n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 2580
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=2580.1n

* CHECK dout0_4 Vdout0_4ck128 = 0 time = 2580
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=2580.1n

* CHECK dout0_5 Vdout0_5ck128 = 1.8 time = 2580
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=2580.1n

* CHECK dout0_6 Vdout0_6ck128 = 1.8 time = 2580
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=2580.1n

* CHECK dout0_7 Vdout0_7ck128 = 1.8 time = 2580
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=2580.1n

* CHECK dout0_0 Vdout0_0ck131 = 0 time = 2640
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=2640.1n

* CHECK dout0_1 Vdout0_1ck131 = 1.8 time = 2640
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=2640.1n

* CHECK dout0_2 Vdout0_2ck131 = 0 time = 2640
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=2640.1n

* CHECK dout0_3 Vdout0_3ck131 = 1.8 time = 2640
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=2640.1n

* CHECK dout0_4 Vdout0_4ck131 = 1.8 time = 2640
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=2640.1n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 2640
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=2640.1n

* CHECK dout0_6 Vdout0_6ck131 = 1.8 time = 2640
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=2640.1n

* CHECK dout0_7 Vdout0_7ck131 = 1.8 time = 2640
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=2640.1n

* CHECK dout0_0 Vdout0_0ck132 = 0 time = 2660
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=2660.1n

* CHECK dout0_1 Vdout0_1ck132 = 0 time = 2660
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=2660.1n

* CHECK dout0_2 Vdout0_2ck132 = 0 time = 2660
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=2660.1n

* CHECK dout0_3 Vdout0_3ck132 = 0 time = 2660
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=2660.1n

* CHECK dout0_4 Vdout0_4ck132 = 1.8 time = 2660
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=2660.1n

* CHECK dout0_5 Vdout0_5ck132 = 1.8 time = 2660
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=2660.1n

* CHECK dout0_6 Vdout0_6ck132 = 0 time = 2660
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=2660.1n

* CHECK dout0_7 Vdout0_7ck132 = 0 time = 2660
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=2660.1n

* CHECK dout0_0 Vdout0_0ck135 = 0 time = 2720
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=2720.1n

* CHECK dout0_1 Vdout0_1ck135 = 0 time = 2720
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=2720.1n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 2720
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=2720.1n

* CHECK dout0_3 Vdout0_3ck135 = 0 time = 2720
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=2720.1n

* CHECK dout0_4 Vdout0_4ck135 = 0 time = 2720
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=2720.1n

* CHECK dout0_5 Vdout0_5ck135 = 0 time = 2720
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=2720.1n

* CHECK dout0_6 Vdout0_6ck135 = 1.8 time = 2720
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=2720.1n

* CHECK dout0_7 Vdout0_7ck135 = 0 time = 2720
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=2720.1n

* CHECK dout0_0 Vdout0_0ck137 = 0 time = 2760
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=2760.1n

* CHECK dout0_1 Vdout0_1ck137 = 1.8 time = 2760
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=2760.1n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 2760
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=2760.1n

* CHECK dout0_3 Vdout0_3ck137 = 0 time = 2760
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=2760.1n

* CHECK dout0_4 Vdout0_4ck137 = 1.8 time = 2760
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=2760.1n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 2760
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=2760.1n

* CHECK dout0_6 Vdout0_6ck137 = 1.8 time = 2760
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=2760.1n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 2760
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=2760.1n

* CHECK dout0_0 Vdout0_0ck138 = 0 time = 2780
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=2780.1n

* CHECK dout0_1 Vdout0_1ck138 = 1.8 time = 2780
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=2780.1n

* CHECK dout0_2 Vdout0_2ck138 = 0 time = 2780
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=2780.1n

* CHECK dout0_3 Vdout0_3ck138 = 1.8 time = 2780
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=2780.1n

* CHECK dout0_4 Vdout0_4ck138 = 1.8 time = 2780
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=2780.1n

* CHECK dout0_5 Vdout0_5ck138 = 0 time = 2780
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=2780.1n

* CHECK dout0_6 Vdout0_6ck138 = 1.8 time = 2780
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=2780.1n

* CHECK dout0_7 Vdout0_7ck138 = 1.8 time = 2780
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=2780.1n

* CHECK dout0_0 Vdout0_0ck139 = 1.8 time = 2800
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=2800.1n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 2800
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=2800.1n

* CHECK dout0_2 Vdout0_2ck139 = 1.8 time = 2800
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=2800.1n

* CHECK dout0_3 Vdout0_3ck139 = 1.8 time = 2800
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=2800.1n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 2800
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=2800.1n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 2800
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=2800.1n

* CHECK dout0_6 Vdout0_6ck139 = 1.8 time = 2800
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=2800.1n

* CHECK dout0_7 Vdout0_7ck139 = 1.8 time = 2800
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=2800.1n

* CHECK dout0_0 Vdout0_0ck140 = 0 time = 2820
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=2820.1n

* CHECK dout0_1 Vdout0_1ck140 = 1.8 time = 2820
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=2820.1n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 2820
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=2820.1n

* CHECK dout0_3 Vdout0_3ck140 = 0 time = 2820
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=2820.1n

* CHECK dout0_4 Vdout0_4ck140 = 1.8 time = 2820
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=2820.1n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 2820
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=2820.1n

* CHECK dout0_6 Vdout0_6ck140 = 0 time = 2820
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=2820.1n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 2820
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=2820.1n

* CHECK dout0_0 Vdout0_0ck141 = 0 time = 2840
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=2840.1n

* CHECK dout0_1 Vdout0_1ck141 = 1.8 time = 2840
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=2840.1n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 2840
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=2840.1n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 2840
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=2840.1n

* CHECK dout0_4 Vdout0_4ck141 = 1.8 time = 2840
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=2840.1n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 2840
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=2840.1n

* CHECK dout0_6 Vdout0_6ck141 = 1.8 time = 2840
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=2840.1n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 2840
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=2840.1n

* CHECK dout0_0 Vdout0_0ck145 = 1.8 time = 2920
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=2920.1n

* CHECK dout0_1 Vdout0_1ck145 = 0 time = 2920
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=2920.1n

* CHECK dout0_2 Vdout0_2ck145 = 0 time = 2920
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=2920.1n

* CHECK dout0_3 Vdout0_3ck145 = 1.8 time = 2920
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=2920.1n

* CHECK dout0_4 Vdout0_4ck145 = 0 time = 2920
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=2920.1n

* CHECK dout0_5 Vdout0_5ck145 = 1.8 time = 2920
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=2920.1n

* CHECK dout0_6 Vdout0_6ck145 = 1.8 time = 2920
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=2920.1n

* CHECK dout0_7 Vdout0_7ck145 = 1.8 time = 2920
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=2920.1n

* CHECK dout0_0 Vdout0_0ck147 = 1.8 time = 2960
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=2960.1n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 2960
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=2960.1n

* CHECK dout0_2 Vdout0_2ck147 = 0 time = 2960
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=2960.1n

* CHECK dout0_3 Vdout0_3ck147 = 1.8 time = 2960
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=2960.1n

* CHECK dout0_4 Vdout0_4ck147 = 0 time = 2960
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=2960.1n

* CHECK dout0_5 Vdout0_5ck147 = 1.8 time = 2960
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=2960.1n

* CHECK dout0_6 Vdout0_6ck147 = 1.8 time = 2960
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=2960.1n

* CHECK dout0_7 Vdout0_7ck147 = 1.8 time = 2960
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=2960.1n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 2980
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=2980.1n

* CHECK dout0_1 Vdout0_1ck148 = 1.8 time = 2980
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=2980.1n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 2980
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=2980.1n

* CHECK dout0_3 Vdout0_3ck148 = 1.8 time = 2980
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=2980.1n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 2980
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=2980.1n

* CHECK dout0_5 Vdout0_5ck148 = 1.8 time = 2980
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=2980.1n

* CHECK dout0_6 Vdout0_6ck148 = 1.8 time = 2980
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=2980.1n

* CHECK dout0_7 Vdout0_7ck148 = 1.8 time = 2980
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=2980.1n

* CHECK dout0_0 Vdout0_0ck149 = 0 time = 3000
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=3000.1n

* CHECK dout0_1 Vdout0_1ck149 = 1.8 time = 3000
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=3000.1n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 3000
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=3000.1n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 3000
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=3000.1n

* CHECK dout0_4 Vdout0_4ck149 = 1.8 time = 3000
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=3000.1n

* CHECK dout0_5 Vdout0_5ck149 = 0 time = 3000
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=3000.1n

* CHECK dout0_6 Vdout0_6ck149 = 0 time = 3000
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=3000.1n

* CHECK dout0_7 Vdout0_7ck149 = 0 time = 3000
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=3000.1n

* CHECK dout0_0 Vdout0_0ck150 = 0 time = 3020
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=3020.1n

* CHECK dout0_1 Vdout0_1ck150 = 1.8 time = 3020
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=3020.1n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 3020
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=3020.1n

* CHECK dout0_3 Vdout0_3ck150 = 1.8 time = 3020
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=3020.1n

* CHECK dout0_4 Vdout0_4ck150 = 1.8 time = 3020
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=3020.1n

* CHECK dout0_5 Vdout0_5ck150 = 0 time = 3020
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=3020.1n

* CHECK dout0_6 Vdout0_6ck150 = 1.8 time = 3020
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=3020.1n

* CHECK dout0_7 Vdout0_7ck150 = 1.8 time = 3020
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=3020.1n

* CHECK dout0_0 Vdout0_0ck152 = 1.8 time = 3060
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=3060.1n

* CHECK dout0_1 Vdout0_1ck152 = 1.8 time = 3060
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=3060.1n

* CHECK dout0_2 Vdout0_2ck152 = 1.8 time = 3060
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=3060.1n

* CHECK dout0_3 Vdout0_3ck152 = 0 time = 3060
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=3060.1n

* CHECK dout0_4 Vdout0_4ck152 = 0 time = 3060
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=3060.1n

* CHECK dout0_5 Vdout0_5ck152 = 1.8 time = 3060
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=3060.1n

* CHECK dout0_6 Vdout0_6ck152 = 1.8 time = 3060
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=3060.1n

* CHECK dout0_7 Vdout0_7ck152 = 1.8 time = 3060
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=3060.1n

* CHECK dout0_0 Vdout0_0ck153 = 1.8 time = 3080
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=3080.1n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 3080
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=3080.1n

* CHECK dout0_2 Vdout0_2ck153 = 1.8 time = 3080
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=3080.1n

* CHECK dout0_3 Vdout0_3ck153 = 1.8 time = 3080
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=3080.1n

* CHECK dout0_4 Vdout0_4ck153 = 0 time = 3080
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=3080.1n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 3080
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=3080.1n

* CHECK dout0_6 Vdout0_6ck153 = 1.8 time = 3080
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=3080.1n

* CHECK dout0_7 Vdout0_7ck153 = 1.8 time = 3080
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=3080.1n

* CHECK dout0_0 Vdout0_0ck155 = 1.8 time = 3120
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=3120.1n

* CHECK dout0_1 Vdout0_1ck155 = 1.8 time = 3120
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=3120.1n

* CHECK dout0_2 Vdout0_2ck155 = 0 time = 3120
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=3120.1n

* CHECK dout0_3 Vdout0_3ck155 = 1.8 time = 3120
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=3120.1n

* CHECK dout0_4 Vdout0_4ck155 = 1.8 time = 3120
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=3120.1n

* CHECK dout0_5 Vdout0_5ck155 = 0 time = 3120
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=3120.1n

* CHECK dout0_6 Vdout0_6ck155 = 1.8 time = 3120
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=3120.1n

* CHECK dout0_7 Vdout0_7ck155 = 1.8 time = 3120
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=3120.1n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 3180
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=3180.1n

* CHECK dout0_1 Vdout0_1ck158 = 1.8 time = 3180
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=3180.1n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 3180
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=3180.1n

* CHECK dout0_3 Vdout0_3ck158 = 1.8 time = 3180
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=3180.1n

* CHECK dout0_4 Vdout0_4ck158 = 1.8 time = 3180
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=3180.1n

* CHECK dout0_5 Vdout0_5ck158 = 0 time = 3180
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=3180.1n

* CHECK dout0_6 Vdout0_6ck158 = 1.8 time = 3180
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=3180.1n

* CHECK dout0_7 Vdout0_7ck158 = 1.8 time = 3180
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=3180.1n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 3260
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=3260.1n

* CHECK dout0_1 Vdout0_1ck162 = 1.8 time = 3260
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=3260.1n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 3260
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=3260.1n

* CHECK dout0_3 Vdout0_3ck162 = 1.8 time = 3260
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=3260.1n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 3260
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=3260.1n

* CHECK dout0_5 Vdout0_5ck162 = 1.8 time = 3260
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=3260.1n

* CHECK dout0_6 Vdout0_6ck162 = 1.8 time = 3260
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=3260.1n

* CHECK dout0_7 Vdout0_7ck162 = 1.8 time = 3260
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=3260.1n

* CHECK dout0_0 Vdout0_0ck163 = 0 time = 3280
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=3280.1n

* CHECK dout0_1 Vdout0_1ck163 = 1.8 time = 3280
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=3280.1n

* CHECK dout0_2 Vdout0_2ck163 = 0 time = 3280
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=3280.1n

* CHECK dout0_3 Vdout0_3ck163 = 1.8 time = 3280
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=3280.1n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 3280
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=3280.1n

* CHECK dout0_5 Vdout0_5ck163 = 1.8 time = 3280
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=3280.1n

* CHECK dout0_6 Vdout0_6ck163 = 1.8 time = 3280
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=3280.1n

* CHECK dout0_7 Vdout0_7ck163 = 1.8 time = 3280
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=3280.1n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 3320
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=3320.1n

* CHECK dout0_1 Vdout0_1ck165 = 0 time = 3320
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=3320.1n

* CHECK dout0_2 Vdout0_2ck165 = 1.8 time = 3320
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=3320.1n

* CHECK dout0_3 Vdout0_3ck165 = 1.8 time = 3320
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=3320.1n

* CHECK dout0_4 Vdout0_4ck165 = 0 time = 3320
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=3320.1n

* CHECK dout0_5 Vdout0_5ck165 = 0 time = 3320
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=3320.1n

* CHECK dout0_6 Vdout0_6ck165 = 1.8 time = 3320
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=3320.1n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 3320
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=3320.1n

* CHECK dout0_0 Vdout0_0ck166 = 0 time = 3340
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=3340.1n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 3340
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=3340.1n

* CHECK dout0_2 Vdout0_2ck166 = 1.8 time = 3340
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=3340.1n

* CHECK dout0_3 Vdout0_3ck166 = 1.8 time = 3340
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=3340.1n

* CHECK dout0_4 Vdout0_4ck166 = 1.8 time = 3340
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=3340.1n

* CHECK dout0_5 Vdout0_5ck166 = 1.8 time = 3340
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=3340.1n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 3340
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=3340.1n

* CHECK dout0_7 Vdout0_7ck166 = 1.8 time = 3340
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=3340.1n

* CHECK dout0_0 Vdout0_0ck169 = 1.8 time = 3400
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=3400.1n

* CHECK dout0_1 Vdout0_1ck169 = 1.8 time = 3400
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=3400.1n

* CHECK dout0_2 Vdout0_2ck169 = 1.8 time = 3400
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=3400.1n

* CHECK dout0_3 Vdout0_3ck169 = 1.8 time = 3400
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=3400.1n

* CHECK dout0_4 Vdout0_4ck169 = 1.8 time = 3400
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=3400.1n

* CHECK dout0_5 Vdout0_5ck169 = 1.8 time = 3400
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=3400.1n

* CHECK dout0_6 Vdout0_6ck169 = 1.8 time = 3400
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=3400.1n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 3400
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=3400.1n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 3460
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=3460.1n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 3460
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=3460.1n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 3460
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=3460.1n

* CHECK dout0_3 Vdout0_3ck172 = 0 time = 3460
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=3460.1n

* CHECK dout0_4 Vdout0_4ck172 = 1.8 time = 3460
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=3460.1n

* CHECK dout0_5 Vdout0_5ck172 = 1.8 time = 3460
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=3460.1n

* CHECK dout0_6 Vdout0_6ck172 = 0 time = 3460
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=3460.1n

* CHECK dout0_7 Vdout0_7ck172 = 1.8 time = 3460
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=3460.1n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 3500
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=3500.1n

* CHECK dout0_1 Vdout0_1ck174 = 0 time = 3500
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=3500.1n

* CHECK dout0_2 Vdout0_2ck174 = 1.8 time = 3500
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=3500.1n

* CHECK dout0_3 Vdout0_3ck174 = 1.8 time = 3500
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=3500.1n

* CHECK dout0_4 Vdout0_4ck174 = 1.8 time = 3500
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=3500.1n

* CHECK dout0_5 Vdout0_5ck174 = 1.8 time = 3500
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=3500.1n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 3500
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=3500.1n

* CHECK dout0_7 Vdout0_7ck174 = 0 time = 3500
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=3500.1n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 3540
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=3540.1n

* CHECK dout0_1 Vdout0_1ck176 = 0 time = 3540
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=3540.1n

* CHECK dout0_2 Vdout0_2ck176 = 1.8 time = 3540
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=3540.1n

* CHECK dout0_3 Vdout0_3ck176 = 1.8 time = 3540
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=3540.1n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 3540
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=3540.1n

* CHECK dout0_5 Vdout0_5ck176 = 0 time = 3540
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=3540.1n

* CHECK dout0_6 Vdout0_6ck176 = 1.8 time = 3540
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=3540.1n

* CHECK dout0_7 Vdout0_7ck176 = 1.8 time = 3540
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=3540.1n

* CHECK dout0_0 Vdout0_0ck178 = 0 time = 3580
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=3580.1n

* CHECK dout0_1 Vdout0_1ck178 = 1.8 time = 3580
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=3580.1n

* CHECK dout0_2 Vdout0_2ck178 = 1.8 time = 3580
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=3580.1n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 3580
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=3580.1n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 3580
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=3580.1n

* CHECK dout0_5 Vdout0_5ck178 = 1.8 time = 3580
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=3580.1n

* CHECK dout0_6 Vdout0_6ck178 = 1.8 time = 3580
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=3580.1n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 3580
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=3580.1n

* CHECK dout0_0 Vdout0_0ck180 = 1.8 time = 3620
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=3620.1n

* CHECK dout0_1 Vdout0_1ck180 = 1.8 time = 3620
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=3620.1n

* CHECK dout0_2 Vdout0_2ck180 = 1.8 time = 3620
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=3620.1n

* CHECK dout0_3 Vdout0_3ck180 = 1.8 time = 3620
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=3620.1n

* CHECK dout0_4 Vdout0_4ck180 = 1.8 time = 3620
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=3620.1n

* CHECK dout0_5 Vdout0_5ck180 = 1.8 time = 3620
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=3620.1n

* CHECK dout0_6 Vdout0_6ck180 = 1.8 time = 3620
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=3620.1n

* CHECK dout0_7 Vdout0_7ck180 = 0 time = 3620
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=3620.1n

* CHECK dout0_0 Vdout0_0ck182 = 0 time = 3660
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=3660.1n

* CHECK dout0_1 Vdout0_1ck182 = 0 time = 3660
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=3660.1n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 3660
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=3660.1n

* CHECK dout0_3 Vdout0_3ck182 = 0 time = 3660
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=3660.1n

* CHECK dout0_4 Vdout0_4ck182 = 1.8 time = 3660
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=3660.1n

* CHECK dout0_5 Vdout0_5ck182 = 1.8 time = 3660
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=3660.1n

* CHECK dout0_6 Vdout0_6ck182 = 0 time = 3660
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=3660.1n

* CHECK dout0_7 Vdout0_7ck182 = 0 time = 3660
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=3660.1n

* CHECK dout0_0 Vdout0_0ck184 = 1.8 time = 3700
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=3700.1n

* CHECK dout0_1 Vdout0_1ck184 = 0 time = 3700
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=3700.1n

* CHECK dout0_2 Vdout0_2ck184 = 1.8 time = 3700
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=3700.1n

* CHECK dout0_3 Vdout0_3ck184 = 0 time = 3700
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=3700.1n

* CHECK dout0_4 Vdout0_4ck184 = 0 time = 3700
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=3700.1n

* CHECK dout0_5 Vdout0_5ck184 = 1.8 time = 3700
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=3700.1n

* CHECK dout0_6 Vdout0_6ck184 = 0 time = 3700
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=3700.1n

* CHECK dout0_7 Vdout0_7ck184 = 1.8 time = 3700
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=3700.1n

* CHECK dout0_0 Vdout0_0ck185 = 0 time = 3720
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=3720.1n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 3720
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=3720.1n

* CHECK dout0_2 Vdout0_2ck185 = 1.8 time = 3720
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=3720.1n

* CHECK dout0_3 Vdout0_3ck185 = 1.8 time = 3720
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=3720.1n

* CHECK dout0_4 Vdout0_4ck185 = 1.8 time = 3720
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=3720.1n

* CHECK dout0_5 Vdout0_5ck185 = 1.8 time = 3720
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=3720.1n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 3720
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=3720.1n

* CHECK dout0_7 Vdout0_7ck185 = 1.8 time = 3720
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=3720.1n

* CHECK dout0_0 Vdout0_0ck187 = 1.8 time = 3760
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=3760.1n

* CHECK dout0_1 Vdout0_1ck187 = 0 time = 3760
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=3760.1n

* CHECK dout0_2 Vdout0_2ck187 = 0 time = 3760
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=3760.1n

* CHECK dout0_3 Vdout0_3ck187 = 0 time = 3760
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=3760.1n

* CHECK dout0_4 Vdout0_4ck187 = 0 time = 3760
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=3760.1n

* CHECK dout0_5 Vdout0_5ck187 = 0 time = 3760
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=3760.1n

* CHECK dout0_6 Vdout0_6ck187 = 1.8 time = 3760
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=3760.1n

* CHECK dout0_7 Vdout0_7ck187 = 1.8 time = 3760
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=3760.1n

* CHECK dout0_0 Vdout0_0ck191 = 1.8 time = 3840
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=3840.1n

* CHECK dout0_1 Vdout0_1ck191 = 0 time = 3840
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=3840.1n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 3840
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=3840.1n

* CHECK dout0_3 Vdout0_3ck191 = 0 time = 3840
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=3840.1n

* CHECK dout0_4 Vdout0_4ck191 = 0 time = 3840
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=3840.1n

* CHECK dout0_5 Vdout0_5ck191 = 0 time = 3840
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=3840.1n

* CHECK dout0_6 Vdout0_6ck191 = 1.8 time = 3840
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=3840.1n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 3840
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=3840.1n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 3860
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=3860.1n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 3860
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=3860.1n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 3860
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=3860.1n

* CHECK dout0_3 Vdout0_3ck192 = 0 time = 3860
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=3860.1n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 3860
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=3860.1n

* CHECK dout0_5 Vdout0_5ck192 = 1.8 time = 3860
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=3860.1n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 3860
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=3860.1n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 3860
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=3860.1n

* CHECK dout0_0 Vdout0_0ck193 = 1.8 time = 3880
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=3880.1n

* CHECK dout0_1 Vdout0_1ck193 = 1.8 time = 3880
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=3880.1n

* CHECK dout0_2 Vdout0_2ck193 = 1.8 time = 3880
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=3880.1n

* CHECK dout0_3 Vdout0_3ck193 = 1.8 time = 3880
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=3880.1n

* CHECK dout0_4 Vdout0_4ck193 = 1.8 time = 3880
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=3880.1n

* CHECK dout0_5 Vdout0_5ck193 = 1.8 time = 3880
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=3880.1n

* CHECK dout0_6 Vdout0_6ck193 = 1.8 time = 3880
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=3880.1n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 3880
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=3880.1n

* CHECK dout0_0 Vdout0_0ck194 = 0 time = 3900
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=3900.1n

* CHECK dout0_1 Vdout0_1ck194 = 1.8 time = 3900
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=3900.1n

* CHECK dout0_2 Vdout0_2ck194 = 0 time = 3900
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=3900.1n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 3900
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=3900.1n

* CHECK dout0_4 Vdout0_4ck194 = 1.8 time = 3900
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=3900.1n

* CHECK dout0_5 Vdout0_5ck194 = 0 time = 3900
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=3900.1n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 3900
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=3900.1n

* CHECK dout0_7 Vdout0_7ck194 = 0 time = 3900
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=3900.1n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 3920
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=3920.1n

* CHECK dout0_1 Vdout0_1ck195 = 1.8 time = 3920
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=3920.1n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 3920
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=3920.1n

* CHECK dout0_3 Vdout0_3ck195 = 0 time = 3920
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=3920.1n

* CHECK dout0_4 Vdout0_4ck195 = 1.8 time = 3920
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=3920.1n

* CHECK dout0_5 Vdout0_5ck195 = 0 time = 3920
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=3920.1n

* CHECK dout0_6 Vdout0_6ck195 = 0 time = 3920
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=3920.1n

* CHECK dout0_7 Vdout0_7ck195 = 0 time = 3920
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=3920.1n

* CHECK dout0_0 Vdout0_0ck198 = 1.8 time = 3980
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=3980.1n

* CHECK dout0_1 Vdout0_1ck198 = 0 time = 3980
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=3980.1n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 3980
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=3980.1n

* CHECK dout0_3 Vdout0_3ck198 = 1.8 time = 3980
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=3980.1n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 3980
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=3980.1n

* CHECK dout0_5 Vdout0_5ck198 = 1.8 time = 3980
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=3980.1n

* CHECK dout0_6 Vdout0_6ck198 = 1.8 time = 3980
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=3980.1n

* CHECK dout0_7 Vdout0_7ck198 = 1.8 time = 3980
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=3980.1n

* CHECK dout0_0 Vdout0_0ck200 = 0 time = 4020
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=4020.1n

* CHECK dout0_1 Vdout0_1ck200 = 0 time = 4020
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=4020.1n

* CHECK dout0_2 Vdout0_2ck200 = 0 time = 4020
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=4020.1n

* CHECK dout0_3 Vdout0_3ck200 = 0 time = 4020
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=4020.1n

* CHECK dout0_4 Vdout0_4ck200 = 1.8 time = 4020
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=4020.1n

* CHECK dout0_5 Vdout0_5ck200 = 1.8 time = 4020
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=4020.1n

* CHECK dout0_6 Vdout0_6ck200 = 0 time = 4020
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=4020.1n

* CHECK dout0_7 Vdout0_7ck200 = 0 time = 4020
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=4020.1n

* CHECK dout0_0 Vdout0_0ck201 = 0 time = 4040
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=4040.1n

* CHECK dout0_1 Vdout0_1ck201 = 1.8 time = 4040
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=4040.1n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 4040
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=4040.1n

* CHECK dout0_3 Vdout0_3ck201 = 0 time = 4040
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=4040.1n

* CHECK dout0_4 Vdout0_4ck201 = 1.8 time = 4040
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=4040.1n

* CHECK dout0_5 Vdout0_5ck201 = 0 time = 4040
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=4040.1n

* CHECK dout0_6 Vdout0_6ck201 = 0 time = 4040
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=4040.1n

* CHECK dout0_7 Vdout0_7ck201 = 0 time = 4040
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=4040.1n

* CHECK dout0_0 Vdout0_0ck203 = 0 time = 4080
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=4080.1n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 4080
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=4080.1n

* CHECK dout0_2 Vdout0_2ck203 = 1.8 time = 4080
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=4080.1n

* CHECK dout0_3 Vdout0_3ck203 = 1.8 time = 4080
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=4080.1n

* CHECK dout0_4 Vdout0_4ck203 = 1.8 time = 4080
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=4080.1n

* CHECK dout0_5 Vdout0_5ck203 = 1.8 time = 4080
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=4080.1n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 4080
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=4080.1n

* CHECK dout0_7 Vdout0_7ck203 = 1.8 time = 4080
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=4080.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
